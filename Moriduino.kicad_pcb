# Repository akita11/Moriduino

File README.md:

# Moriduino

どこかのゲーム中の電子工作セットに出てくるArduino的ななにか。一応ArduinoUNO互換機として使えます。

## KiCad design Moriduino.kicad_pcb

Parts:
C1, C2: CP1; CP_Elec_5x4.5
C3, C4: 0.1u; C_0603_1608Metric
C5, C6: 10p; C_0603_1608Metric
CN1: CON_USB-C-16; USB-C_16P_TH
CN2: CON_AVRISP; PinHeader_2x03_P2.54mm_Vertical
D1, D2, D3, D4: LED; LED_0603_1608Metric
D5: D; D_1206_3216Metric
F1: Polyfuse; R_1210_3225Metric
J1: USB_B; USB_B_OST_USB-B1HSxx_Horizontal
J2: Barrel_Jack_Switch; BarrelJack_Horizontal
P1: Power; PinSocket_1x08_P2.54mm_Vertical
P2: Analog; PinSocket_1x06_P2.54mm_Vertical
P3: Digital; PinSocket_1x10_P2.54mm_Vertical
P4: Digital; PinSocket_1x08_P2.54mm_Vertical
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
Q1: FDN340P; SOT-23; MPN FDN340P
R1, R2: 10k; R_0603_1608Metric
R3, R4: 5.1k; R_0603_1608Metric
R5, R6, R7, R8, R9, R10, R11: 1k; R_0603_1608Metric
U1: AP1117-50; SOT-223-3_TabPin2
U2: LMV358; SO-8_5.3x6.2mm_P1.27mm
U3: IC_FT232RQ; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm_ThermalVias
U4: ATmega328P-PU; DIP-28_W7.62mm
U5: LDO_5p_NJM2865; SOT-23-5
Y1: 16MHz; HC49US

Connections:
+3V3: C2.1, P1.4, U2.2 (-), U5.4 (VO)
+5V: CN2.2 (VDD), D1.2 (A), D2.2 (A), D3.2 (A), P1.2, P1.5, Q1.3 (D), R10.2, U1.2 (VO), U2.8 (V+), U3.1 (VCC), U3.18 (~RESET), U3.19 (VCCIO), U4.7 (VCC), U4.20 (AVCC), U5.1 (EN), U5.5 (VI)
/A0: P2.1, U4.23 (PC0)
/A1: P2.2, U4.24 (PC1)
/A2: P2.3, U4.25 (PC2)
/A3: P2.4, U4.26 (PC3)
/A4: P2.5, P3.2, U4.27 (PC4)
/A5: P2.6, P3.1, U4.28 (PC5)
/AREF: P3.3, U4.21 (AREF)
/D0: P4.8, R6.1, U4.2 (PD0)
/D1: P4.7, R7.1, U4.3 (PD1)
/D2: P4.6, U4.4 (PD2)
/D3: P4.5, U4.5 (PD3)
/D4: P4.4, U4.6 (PD4)
/D5: P4.3, U4.11 (PD5)
/D6: P4.2, U4.12 (PD6)
/D7: P4.1, U4.13 (PD7)
/D8: P3.10, U4.14 (PB0)
/D9: P3.9, U4.15 (PB1)
/D10: P3.8, U4.16 (PB2)
/D11: CN2.4 (MOSI), P3.7, U4.17 (PB3)
/D12: CN2.1 (MISO), P3.6, U4.18 (PB4)
/D13: CN2.3 (SCK), P3.5, U2.5 (+), U4.19 (PB5)
/RST: C4.1, CN2.5 (RST), P1.3, R10.1, U4.1 (~RESET~/PC6)
/USB_DM: CN1.A7 (DN1), CN1.B7 (DN2), J1.2 (D-), U3.15 (USBDM)
/USB_DP: CN1.A6 (DP1), CN1.B6 (DP2), J1.3 (D+), U3.14 (USBDP)
/VBUS: CN1.A4 (VBUS1), CN1.A9 (VBUS2), F1.2, J1.1 (VBUS)
/VIN: C1.1, D5.1 (K), P1.8, R1.2, U1.3 (VI)
GND: C1.2, C2.2, C3.1, C5.1, C6.1, CN1.A1 (GND1), CN1.A12 (GND2), CN1.FG, CN2.6 (GND), D4.1 (K), J1.4 (GND), J1.5 (Shield), J2.2, P1.6, P1.7, P3.4, R2.1, R3.1, R4.1, R5.1, U1.1 (GND), U2.4 (V-), U3.4 (GND), U3.17 (GND@1), U3.20 (GND@2), U3.24 (GND@A), U3.26 (TEST), U3.33 (GND(e)), U4.8 (GND), U4.22 (GND), U5.2 (GND)
unnamed: C3.2, U3.16 (3V3OUT)
unnamed: C4.2, U3.31 (~DTR)
unnamed: C5.2, U4.10 (XTAL2/PB7), Y1.1
unnamed: C6.2, U4.9 (XTAL1/PB6), Y1.2
unnamed: CN1.A5 (CC1), R4.2
unnamed: CN1.B5 (CC2), R3.2
unnamed: D1.1 (K), R5.2
unnamed: D2.1 (K), R8.1
unnamed: D3.1 (K), R9.1
unnamed: D4.2 (A), R11.2
unnamed: D5.2 (A), J2.1
unnamed: F1.1, Q1.2 (S)
unnamed: Q1.1 (G), U2.1
unnamed: R1.1, R2.2, U2.3 (+)
unnamed: R6.2, U3.30 (TXD)
unnamed: R7.2, U3.2 (RXD)
unnamed: R8.2, U3.22 (CBUS0)
unnamed: R9.2, U3.21 (CBUS1)
unnamed: R11.1, U2.6 (-), U2.7

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.
SDA
SCL
SCK
MISO
MOSI

Board: 2 copper layers, 68.6 x 53.3 mm, 41 parts (0 on the bottom side), 48 nets.

## Commit log

2020-05-18 1st commit
2020-05-18 回路図完成、アートワークは目立つ配線のみ
2020-05-18 配線を少し進めた
2020-05-18 一通り完成
2020-05-27 配線ミスを修正しベタGNDを追加
2020-06-05 pMOSの向きが逆だったのを修正
